options:
  parameters:
    description: Monitor Iridium Ring Channel
    generate_options: qt_gui
    id: iridium_ring_monitor
    output_language: python
    title: Iridium Ring Monitor
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1626.2708e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: FFT Spectrum
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    bw0: samp_rate
    center_freq0: center_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
