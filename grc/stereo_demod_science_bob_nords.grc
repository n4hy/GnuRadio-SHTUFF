options:
  parameters:
    generate_options: qt_gui
    id: testursp
    output_language: python
    title: FM Stereo Receiver
  states: {}

blocks:
- name: Volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '.4'
    widget: eng_slider
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 87.9e6
    step: '25000'
    stop: 107.9e6
    value: 103.7e6
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19.05e3
    low_cutoff_freq: 18.95e3
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '5'
    gain: Volume
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '5'
    gain: Volume
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: FM Stereo Multiplex
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: FM Stereo Channel
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '24'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '24'
    type: fff
  states: {}
- name: uhd_usrp_source_1_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    bw0: 250e3
    center_freq0: frequency
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '50'
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', blocks_float_to_complex_0, '0']
- [analog_wfm_rcv_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_real_0_1, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_0_1, '0', blocks_sub_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '1']
- [uhd_usrp_source_1_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_1_0, '0', qtgui_freq_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
